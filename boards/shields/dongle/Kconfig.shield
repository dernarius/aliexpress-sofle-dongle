## boards/shields/dongle/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_DONGLE
    def_bool $(shields_list_contains,dongle)
```
